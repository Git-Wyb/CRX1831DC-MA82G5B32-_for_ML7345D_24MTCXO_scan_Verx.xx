# Keil uVision project CRX1831DCM_MA82G5B32_Pro.uvproj, settings and files
target Target 1 (MCS-51)
  device: MA82G5B32 Megawin
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) XRAM (0-0x06FF) CLOCK(25000000)
  output: CRX1831DCM_MA82G5B32_Pro +hex
  c flags: SizeSpeed=1
  c include: .\include;.\user\inc
  group user
    ./user/src/: main.c sys.c gpio.c timer.c uart.c IAP_flash.c spi.c ram.c ID_Decode.c ML7345.c ML7345_HAL.c
